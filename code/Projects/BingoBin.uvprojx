# Keil uVision project BingoBin.uvprojx, settings and files
target BingoBin_STM32F030C8T6 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BingoBin +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Drivers\STM32F0xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers\BSP\Inc;..\Application\Inc;..\Drivers\BSP\Inc\w5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../Application/Src/: app_communication.c app_lock.c app_w5500.c stm32f0xx_it.c app_info.c app_meter.c main.c stm32f0xx_hal_msp.c app_lightbox.c app_infrared.c
  group Config
    ../Application/Inc/: config.h stm32f0xx_hal_conf.h
  group Drivers/BSP/BingoBin
    ../Drivers/BSP/Src/: adc.c timer.c usart.c spi.c socket.c w5500.c wizchip_conf.c led.c flash.c m485.c pwm.c smoke.c iwdg.c ir_nec_send.c ir_rc5_send.c ir_receiver.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart.c stm32f0xx_hal_usart.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Example/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
